# Keil uVision project Demon.uvprojx, settings and files
target Demon Car (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Public;.\Hardwork\led;.\Hardwork\can;.\Hardwork\OLED;.\Hardwork\ps2;.\APP\time;.\APP\CAN_receive;.\APP\pid;.\APP\usart;.\APP\control
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_it.c
  group APP
    ./APP/CAN_receive/: CAN_Receive.c
    ./APP/pid/: pid.c
    ./APP/time/: time.c
    ./APP/usart/: usart.c
    ./APP/control/: control.c
  group Hardware
    ./Hardwork/can/: can.c
    ./Hardwork/led/: led.c
    ./Hardwork/OLED/: oled.c
    ./Hardwork/ps2/: ps2.c
  group Public
    ./Public/: system.c SysTick.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_md.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_can.c stm32f10x_i2c.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
